Commit message: 添加轨迹绘制功能和大气，重力

File: urdf/rigid_body.urdf (robot description, URDF)
Before this commit: robot rigid_body, 2 links, 1 joints
Links:
- link base_link: geometry visual box size=1 0.25 0.25
